# Keil uVision project ir_learning_remote.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: ir_learning_remote +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\My_Libraries\LCD;.\My_Libraries\Device Header Files;.\My_Libraries\EEPROM
  group Source Group 1
    ./: STARTUP.A51 main.c
